# Keil uVision project kdl.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kdl
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\src\inc;..\..\STM32L1xx_PLib\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: i2c.c main.c tools.c uc1601s.c ui.c
  group Lib
    ../../STM32L1xx_PLib/Objects/: STM32L151_Lib.lib
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Device:Startup 1.0.0
